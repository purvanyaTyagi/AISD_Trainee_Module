Commit message: New changes

File: my_src/my_robot_description/urdf/robot.urdf (robot description, URDF)
Before this commit: robot my_custom_robot, 8 links, 7 joints
Joints:
- joint chassis_joint: origin xyz=0 0 0.1 -> xyz=0 0 0.15
